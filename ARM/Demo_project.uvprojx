# Keil uVision project Demo_project.uvprojx, settings and files
target nrf51822_xxAA_Demo_project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Demo_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10000
  c include: ..\Include;..\Core;..\Include\esb;..\APP;..\user;..\Sys
  asm include: --libpath "C:\Keil_v5\ARM\ARMCC\lib"
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Source/templates/arm/: arm_startup_nrf51.s
  group Core
    ../Source/templates/: system_nrf51.c
    ../Core/: core_cm0.h core_cmFunc.h core_cmInstr.h core_cmSimd.h cmsis_armcc.h
  group Lib
    ../Source/nrf_delay/: nrf_delay.c
    ../Source/simple_uart/: simple_uart.c
  group App
    ../APP/: gpio.c gpio.h time.c time.h rf.c rf.h
  group Sys
    ../Sys/: Sys.c Sys.h uart.c uart.h
  group User
    ../user/: main_tx.c radio_config.c radio_config.h
  group ReadME
    ../ReadME/: ReadME.txt
